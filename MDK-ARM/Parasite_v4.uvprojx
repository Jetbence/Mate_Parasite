# Keil uVision project Parasite_v4.uvprojx, settings and files
target Parasite_v4 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030K6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: Parasite_v4
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F030x6
  c include: ../Inc; ../Drivers/STM32F0xx_HAL_Driver/Inc; ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F0xx/Include; ../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Application/MDK-ARM
    ./: startup_stm32f030x6.s
  group Application/User
    ../Src/: stm32f0xx_hal_msp.c main.c stm32f0xx_it.c STM32R_SignalMainSwitch.c PCF8563.c PCF8563.h LPF.c
    ../Inc/: LPF.h
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_gpio.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_dma.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal.c stm32f0xx_hal_uart.c stm32f0xx_hal_i2c.c stm32f0xx_hal_pwr.c stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_cortex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_flash.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f0xx.c
software components: CMSIS:CORE 4.3.0
